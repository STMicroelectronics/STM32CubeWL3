<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LPM_Button_UDS.ewp</path>  </project>
<batchBuild></batchBuild>
</workspace>
