# Keil uVision project USART_Communication_Rx_IT_Continuous_Init.uvprojx, settings and files
target USART_Communication_Rx_IT_Continuous_Init (6190000::V6.19::ARMCLANG)
  device: STM32WL3RKBVx STMicroelectronics
  pack: Keil.STM32WL3x_DFP.1.3.0-RC1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x10040000-0x1005FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+") TZ
  output: USART_Communication_Rx_IT_Continuous_Init +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=48000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,ART_ACCELERATOR_ENABLE=0,STM32WL3RX,CFG_HW_RCC_HSE_CAPACITOR_TUNE=32
  c misc: -fshort-enums
  c include: ../Inc;../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WL3X/Include;../../../../../../Drivers/CMSIS/Include
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: stm32wl3rxx_flash.sct
  link misc: --diag_suppress=L6312,L6314,L6329,L1215
  group Application/MDK-ARM
    ./: startup_stm32wl3rx.s
  group Application/User
    ../Src/: main.c stm32wl3x_it.c
  group Doc
    ../: README.md
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_ll_utils.c stm32wl3x_ll_gpio.c stm32wl3x_ll_pwr.c stm32wl3x_ll_usart.c stm32wl3x_ll_rcc.c stm32wl3x_ll_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32wl3x.c
software components: CMSIS:CORE 4.3.0
