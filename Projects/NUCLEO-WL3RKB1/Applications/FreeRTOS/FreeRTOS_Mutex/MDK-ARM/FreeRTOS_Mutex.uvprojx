# Keil uVision project FreeRTOS_Mutex.uvprojx, settings and files
target FreeRTOS_Mutex (6180000::V6.18::ARMCLANG)
  device: STM32WL3RKBVx STMicroelectronics
  pack: Keil.STM32WL3x_DFP.1.3.0-RC1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x10040000-0x1005FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+") TZ
  output: FreeRTOS_Mutex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WL3RX
  c misc: -fshort-enums
  c include: ../Inc;../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc;../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM0;../../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WL3X/Include;../../../../../../Drivers/CMSIS/Include
  asm misc: -x assembler-with-cpp
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: stm32wl3rxx_flash.sct
  link misc: --diag_suppress=L6312,L6314,L6329,L1215
  group Application/MDK-ARM
    ./: startup_stm32wl3rx.s
  group Application/User
    ../Src/: main.c freertos.c stm32wl3x_it.c stm32wl3x_hal_msp.c stm32wl3x_hal_timebase_tim.c
  group Doc
    ../: README.md
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_hal_tim.c stm32wl3x_hal_tim_ex.c stm32wl3x_hal_cortex.c stm32wl3x_hal_rcc.c stm32wl3x_hal_rcc_ex.c stm32wl3x_hal_flash.c stm32wl3x_hal_flash_ex.c stm32wl3x_hal_gpio.c stm32wl3x_hal_dma.c stm32wl3x_hal_pwr.c stm32wl3x_hal_pwr_ex.c stm32wl3x_hal.c stm32wl3x_hal_uart.c stm32wl3x_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wl3x.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM0/: portasm.c port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.3.0
