# Keil uVision project MRSUBG_DatabufferHandler_Rx.uvprojx, settings and files
target MRSUBG_DatabufferHandler_Rx (6180000::V6.18::ARMCLANG)
  device: STM32WL3RKBVx STMicroelectronics
  pack: Keil.STM32WL3x_DFP.1.3.0-RC2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x10040000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MRSUBG_DatabufferHandler_Rx +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WL3RX
  c misc: -Wno-format
  c include: ../Inc;../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc;../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WL3X/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WL3R-Nucleo
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: stm32wl3rxx_flash.sct
  link misc: --diag_suppress=L6312,L6314,L6329,L1215
  group Application/MDK-ARM
    ./: startup_stm32wl3rx.s
  group Application/User
    ../Src/: main.c stm32wl3x_it.c stm32wl3x_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WL3R-Nucleo
    ../../../../../../Drivers/BSP/STM32WL3R-Nucleo/: stm32wl3r_nucleo.c
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_hal_cortex.c stm32wl3x_hal_rcc.c stm32wl3x_hal_rcc_ex.c stm32wl3x_hal_flash.c stm32wl3x_hal_flash_ex.c stm32wl3x_hal_gpio.c stm32wl3x_hal_dma.c stm32wl3x_hal_pwr.c stm32wl3x_hal_pwr_ex.c stm32wl3x_hal.c stm32wl3x_hal_mrsubg.c stm32wl3x_ll_utils.c stm32wl3x_hal_tim.c stm32wl3x_hal_tim_ex.c stm32wl3x_hal_uart.c stm32wl3x_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wl3x.c
