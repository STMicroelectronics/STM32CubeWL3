<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MRSUBG_SequencerAutoAck_Rx.ewp</path>
  </project>
  <batchBuild />
</workspace>
