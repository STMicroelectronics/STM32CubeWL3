# Keil uVision project HAL_TimeBase_RTC_WKUP.uvprojx, settings and files
target HAL_TimeBase_RTC_WKUP (6140001::V6.14.1::ARMCLANG)
  device: STM32WL3RKBVx STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x10040000-0x1005FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+") TZ
  output: HAL_TimeBase_RTC_WKUP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NUCLEO_WL3RKB1,USE_HAL_DRIVER,STM32WL3RX
  c misc: -fshort-enums
  c include: ../Inc;../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc;../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WL3X/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WL3R-Nucleo
  asm misc: -x assembler-with-cpp
  scatter file: stm32wl3rxx_flash.sct
  link misc: --diag_suppress=L6312,L6314,L6329,L1215
  group Application/MDK-ARM
    ./: startup_stm32wl3rx.s
  group Application/User
    ../Src/: stm32wl3x_hal_timebase_rtc_wakeup.c main.c stm32wl3x_it.c stm32wl3x_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WL3R-Nucleo
    ../../../../../../Drivers/BSP/STM32WL3R-Nucleo/: stm32wl3r_nucleo.c
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_hal_rtc.c stm32wl3x_hal_rtc_ex.c stm32wl3x_hal_cortex.c stm32wl3x_hal_rcc.c stm32wl3x_hal_rcc_ex.c stm32wl3x_hal_flash.c stm32wl3x_hal_flash_ex.c stm32wl3x_hal_gpio.c stm32wl3x_hal_dma.c stm32wl3x_hal_pwr.c stm32wl3x_hal_pwr_ex.c stm32wl3x_hal.c stm32wl3x_hal_tim.c stm32wl3x_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wl3x.c
software components: CMSIS:CORE 4.3.0
