# IAR project ADC_TemperatureSensor_Init.ewp, settings and files
configuration ADC_TemperatureSensor_Init (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL33CC ST STM32WL33CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=48000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=0; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; CORE_CM4; STM32WL3XX; HSE_VALUE=48000000; HSI_VALUE=64000000; PREFETCH_ENABLE=1; ART_ACCELERATOR_ENABLE=0; CFG_HW_RCC_HSE_CAPACITOR_TUNE=32
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32WL3X/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_TemperatureSensor_Init.hex
  ILINK.IlinkOutputFile: ADC_TemperatureSensor_Init.out
  ILINK.IlinkIcfFile: stm32wl3xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl3xx.s
  group Application/User
    ../Src/: main.c stm32wl3x_it.c
  group Doc
    ../: readme.txt README.md
  group Drivers/CMSIS
    ../Src/: system_stm32wl3x.c
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_ll_gpio.c stm32wl3x_ll_adc.c stm32wl3x_ll_dma.c stm32wl3x_ll_rcc.c stm32wl3x_ll_utils.c stm32wl3x_ll_pwr.c stm32wl3x_ll_usart.c
