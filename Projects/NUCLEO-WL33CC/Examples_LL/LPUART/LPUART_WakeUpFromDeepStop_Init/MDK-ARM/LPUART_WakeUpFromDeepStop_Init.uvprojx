# Keil uVision project LPUART_WakeUpFromDeepStop_Init.uvprojx, settings and files
target LPUART_WakeUpFromDeepStop_Init (6210000::V6.21::ARMCLANG)
  device: STM32WL33CCVx STMicroelectronics
  pack: Keil.STM32WL3x_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x10040000-0x1007FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+") TZ
  output: LPUART_WakeUpFromDeepStop_Init +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=48000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,ART_ACCELERATOR_ENABLE=0,STM32WL33,CFG_HW_RCC_HSE_CAPACITOR_TUNE=32
  c misc: -fshort-enums
  c include: ../Inc;../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc;../../../../../../Drivers/STM32Wl3x_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WL3X/Include;../../../../../../Drivers/CMSIS/Include
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: stm32wl3xx_flash.sct
  link misc: --diag_suppress=L6312,L6314,L6329,L1215
  group Application/MDK-ARM
    ./: startup_stm32wl3xx.s
  group Application/User
    ../Src/: cpu_context_switch.s device_context_switch.c osal.c stm32_lpm_if.c main.c stm32wl3x_it.c
  group Doc
    ../: README.md
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_ll_gpio.c stm32wl3x_ll_rcc.c stm32wl3x_ll_utils.c stm32wl3x_ll_lpuart.c stm32wl3x_ll_pwr.c
    ../../../../../../Drivers/STM32Wl3x_HAL_Driver/Src/: stm32wl3x_ll_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32wl3x.c
software components: CMSIS:CORE 5.6.0
