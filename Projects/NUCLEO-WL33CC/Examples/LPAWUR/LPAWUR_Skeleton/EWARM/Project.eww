<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LPAWUR_Skeleton.ewp</path>
  </project>
  <batchBuild />
</workspace>
