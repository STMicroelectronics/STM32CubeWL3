# Keil uVision project WmBus_Phy_Meter_RadioTimer.uvprojx, settings and files
target WmBus_Phy_Meter_RadioTimer (6180000::V6.18::ARMCLANG)
  device: STM32WL33CCVx STMicroelectronics
  pack: Keil.STM32WL3x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x0008000) IROM(0x10040000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: WmBus_Phy_Meter_RadioTimer +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WL33,WMBUS_CRC_IN_HAL,WMBUS_NO_BLOCKING_HAL,RADIO_TIMER_ENABLED,PRINT_DEBUG,DEEPSTOP_ENABLE
  c misc: -Wno-format
  c include: ../Core/Inc;../System/Interfaces;../System/Modules;../System/Startup;../WmBus/App;../../../../../../Drivers/BSP/STM32WL3x-Nucleo;../../../../../../Drivers/CMSIS/Device/ST/STM32WL3X/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc;../../../../../../Middlewares/ST/WmBus_Phy/Inc;../../../../../../Utilities/lpm/tiny_lpm
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: stm32wl3xx_flash.sct
  link misc: --diag_suppress=L6312,L6314,L6329,L1215
  group Application/MDK-ARM
    ./: startup_stm32wl3xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wl3x_hal_msp.c stm32wl3x_it.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Application/User/System/Modules
    ../System/Modules/: osal.c
  group Application/User/System/Startup
    ../System/Startup/: cpu_context_switch.s device_context_switch.c
  group Application/User/WmBus/App
    ../WmBus/App/: app_wmbus.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WL3x-Nucleo
    ../../../../../../Drivers/BSP/STM32WL3x-Nucleo/: stm32wl3x_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wl3x.c
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_hal.c stm32wl3x_hal_cortex.c stm32wl3x_hal_dma.c stm32wl3x_hal_gpio.c stm32wl3x_hal_mrsubg.c stm32wl3x_hal_mrsubg_timer.c stm32wl3x_hal_pwr.c stm32wl3x_hal_pwr_ex.c stm32wl3x_hal_rcc.c stm32wl3x_hal_rcc_ex.c stm32wl3x_hal_uart.c stm32wl3x_hal_uart_ex.c stm32wl3x_hal_usart.c stm32wl3x_hal_usart_ex.c stm32wl3x_ll_utils.c
  group Middlewares/ST/WmBus_Phy
    ../../../../../../Middlewares/ST/WmBus_Phy/Src/: stm32wl3_wmbphy_pwr.c stm32wl3_wmbphy_radio.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
