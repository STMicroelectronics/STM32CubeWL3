<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\WmBus_Phy_Meter_Button.ewp</path>
  </project>
<batchBuild></batchBuild>
</workspace>



