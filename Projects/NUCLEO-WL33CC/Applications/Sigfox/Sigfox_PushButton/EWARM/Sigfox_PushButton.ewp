# IAR project Sigfox_PushButton.ewp, settings and files
configuration Sigfox_PushButton (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL33CC ST STM32WL33CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: WL3SFX_PA_DRV_MODE_14dBm; USE_HAL_DRIVER; STM32WL33
  ICCARM.CCIncludePath2: ../../../../../../Utilities/lpm/tiny_lpm; ../Core/Inc; ../Sigfox/App; ../Sigfox/Target; ../System/Interfaces; ../System/Modules; ../System/Startup; ../Drivers/STM32WL3x_HAL_Driver/Inc; ../Drivers/STM32WL3x_HAL_Driver/Inc/Legacy; ../Utilities/lpm/tiny_lpm; ../Drivers/CMSIS/Device/ST/STM32WL3x/Include; ../Middlewares/Third_Party/Sigfox/SigfoxLib; ../Drivers/CMSIS/Include; ..\..\..\..\..\..\Drivers\BSP\STM32WL3x-Nucleo; ../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib; ../../../../../../Drivers/CMSIS/Device/ST/STM32WL3X/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sigfox_PushButton.hex
  ILINK.IlinkOutputFile: Sigfox_PushButton.out
  ILINK.IlinkIcfFile: stm32wl3xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl3xx.s
  group Application/User/Core
    ../Core/Src/: oob_adc.c main.c stm32wl3x_it.c stm32wl3x_hal_msp.c
  group Application/User/Sigfox/App
    ../Sigfox/App/: app_sigfox.c ST_Sigfox.c
  group Application/User/Sigfox/Target
    ../Sigfox/Target/: wl3sfx_databuffers.c wl3sfx_fem.c wl3sfx_flash_utils.c wl3sfx_it.c wl3sfx_log.c wl3sfx_mcu_api.c wl3sfx_nvm.c wl3sfx_nvm_boarddata.c wl3sfx_nvm_records.c wl3sfx_oob.c wl3sfx_pn9tx.c wl3sfx_rf_api.c wl3sfx_rf_state.c wl3sfx_timer.c wl3sfx_txsymbols.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Application/User/System/Modules
    ../System/Modules/: osal.c
  group Application/User/System/Startup
    ../System/Startup/: cpu_context_switch.s device_context_switch.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WL3x-Nucleo
    ../../../../../../Drivers/BSP/STM32WL3x-Nucleo/: stm32wl3x_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wl3x.c
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_hal_adc.c stm32wl3x_hal_rcc.c stm32wl3x_hal_rcc_ex.c stm32wl3x_hal_flash.c stm32wl3x_hal_flash_ex.c stm32wl3x_hal_gpio.c stm32wl3x_hal_dma.c stm32wl3x_hal_pwr.c stm32wl3x_hal_pwr_ex.c stm32wl3x_hal_cortex.c stm32wl3x_hal.c stm32wl3x_hal_mrsubg.c stm32wl3x_ll_utils.c stm32wl3x_hal_rtc.c stm32wl3x_hal_rtc_ex.c stm32wl3x_hal_tim.c stm32wl3x_hal_tim_ex.c stm32wl3x_hal_uart.c stm32wl3x_hal_uart_ex.c
  group Middlewares/Sigfox
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest/: ADDON_V0.8.0_iar_850_arm_FDL_MON_cortexM0+.a
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib/: SFX_LIB_V2.10.0_iar_850_arm_FDL_MON_cortexM0+.a
    ../../../../../../Middlewares/Third_Party/Sigfox/Monarch/: ST_MONARCH_LIB_WL3.a
    ../../../../../../Middlewares/Third_Party/Sigfox/Retriever/: ST_RETRIEVER_LIB_WL3.a
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
  group Utilities/lpm/tiny_lpm
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
