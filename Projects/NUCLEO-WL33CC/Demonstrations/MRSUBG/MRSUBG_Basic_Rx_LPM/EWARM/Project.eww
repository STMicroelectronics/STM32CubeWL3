<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MRSUBG_Basic_Rx_LPM.ewp</path>
  </project>
  <batchBuild />
</workspace>
