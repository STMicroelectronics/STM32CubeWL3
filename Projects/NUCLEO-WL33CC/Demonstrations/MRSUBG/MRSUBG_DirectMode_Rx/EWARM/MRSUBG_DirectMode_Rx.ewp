# IAR project MRSUBG_DirectMode_Rx.ewp, settings and files
configuration MRSUBG_DirectMode (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL33CC ST STM32WL33CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NUCLEO_WL33XX; USE_HAL_DRIVER; STM32WL33; DEBUG
  ICCARM.CCIncludePath2: ../Core/Inc; ../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WL3x-Nucleo; ../../../../../../Drivers/CMSIS/Device/ST/STM32WL3X/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MRSUBG_DirectMode.hex
  ILINK.IlinkOutputFile: MRSUBG_DirectMode.out
  ILINK.IlinkIcfFile: stm32wl3xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl3xx.s
  group Application/User
    ../Core/Src/: app_entry.c main.c stm32wl3x_hal_msp.c stm32wl3x_it.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WL3x-Nucleo
    ../../../../../../Drivers/BSP/STM32WL3x-Nucleo/: stm32wl3x_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wl3x.c
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_hal.c stm32wl3x_hal_cortex.c stm32wl3x_hal_dma.c stm32wl3x_hal_flash.c stm32wl3x_hal_flash_ex.c stm32wl3x_hal_gpio.c stm32wl3x_hal_mrsubg.c stm32wl3x_hal_pwr.c stm32wl3x_hal_pwr_ex.c stm32wl3x_hal_rcc.c stm32wl3x_hal_rcc_ex.c stm32wl3x_hal_tim.c stm32wl3x_hal_tim_ex.c stm32wl3x_hal_uart.c stm32wl3x_hal_uart_ex.c stm32wl3x_hal_usart.c stm32wl3x_hal_usart_ex.c stm32wl3x_ll_utils.c
