# IAR project SFUOTA_ServerYmodem.ewp, settings and files
configuration SFUOTA_ServerYmodem (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL33CC ST STM32WL33CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WL3XX
  ICCARM.CCIncludePath2: ../Core/Inc; ../SFUOTA/Protocol; ../SFUOTA/Target; ../System/Interfaces; ../System/Modules; ../System/Startup; ../../../../../../../Drivers/BSP/STM32WL3x-Nucleo; ../../../../../../../Drivers/CMSIS/Device/ST/STM32WL3X/Include; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc; ../../../../../../../Utilities/lpm/tiny_lpm
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../Binary/SFUOTA_ServerYmodem.bin
  ILINK.IlinkOutputFile: SFUOTA_ServerYmodem.out
  ILINK.IlinkIcfFile: stm32wl3xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl3xx.s
  group Application/User/SFUOTA/Protocol
    ../SFUOTA/Protocol/: sfuota_server.c ymodem.c
  group Application/User/SFUOTA/Target
    ../SFUOTA/Target/: sfuota_radio.c sfuota_image.c
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wl3x_hal_msp.c stm32wl3x_it.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Application/User/System/Modules
    ../System/Modules/: osal.c
  group Application/User/System/Startup
    ../System/Startup/: cpu_context_switch.s device_context_switch.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WL3x-Nucleo
    ../../../../../../../Drivers/BSP/STM32WL3x-Nucleo/: stm32wl3x_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wl3x.c
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_hal.c stm32wl3x_hal_cortex.c stm32wl3x_hal_dma.c stm32wl3x_hal_flash.c stm32wl3x_hal_flash_ex.c stm32wl3x_hal_gpio.c stm32wl3x_hal_mrsubg.c stm32wl3x_hal_pwr.c stm32wl3x_hal_pwr_ex.c stm32wl3x_hal_rcc.c stm32wl3x_hal_rcc_ex.c stm32wl3x_hal_uart.c stm32wl3x_hal_uart_ex.c stm32wl3x_ll_utils.c
  group Utilities
    ../../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
