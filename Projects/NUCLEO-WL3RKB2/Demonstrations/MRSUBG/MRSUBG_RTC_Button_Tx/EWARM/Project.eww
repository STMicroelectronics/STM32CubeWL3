<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MRSUBG_RTC_Button_Tx.ewp</path>
  </project>
<batchBuild></batchBuild>
</workspace>



